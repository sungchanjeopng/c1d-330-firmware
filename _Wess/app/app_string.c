//------------------------------------------------------------------------------------------------------------------------------
//  Copyright (C) 2021, WESS-Global Inc., All Rights Reserved.
//
//  The information contained herein is confidential property of WESS-Global Inc. The use, copying, transfer or disclosure of
//  such information is prohibited except by express written agreement with WESS-Global Co.,LTD
//
//  $ Date: 2020-07-13 12:00:00 +0900 $
//------------------------------------------------------------------------------------------------------------------------------


//------------------------------------------------------------------------------------------------------------------------------
//  Includes
//------------------------------------------------------------------------------------------------------------------------------
// self
#include "app_string.h"


//------------------------------------------------------------------------------------------------------------------------------
//  Global variables
//------------------------------------------------------------------------------------------------------------------------------


//------------------------------------------------------------------------------------------------------------------------------
//  Local variables
//------------------------------------------------------------------------------------------------------------------------------
I08 lStr_buff[16];


//------------------------------------------------------------------------------------------------------------------------------
//  Local Funtions
//------------------------------------------------------------------------------------------------------------------------------


//------------------------------------------------------------------------------------------------------------------------------
//  Global APIs - Access Local Variables
//------------------------------------------------------------------------------------------------------------------------------
// Get
// Set


//------------------------------------------------------------------------------------------------------------------------------
//  Global APIs - Operation
//------------------------------------------------------------------------------------------------------------------------------
void STR_InitVari(void)
{

}

I08* STR_Num2Str(S64 numb, U32 digit, U08 decimal, U08 f_fill)
{
	U08 i;
    U08 dg_num;
	U64 pow = 1;

	for(i=0; i<(digit-1); i++)
		pow *= 10;

	if  (decimal == 0)		dg_num = digit;
	else					dg_num = digit + 1;

	for(i=0; i<dg_num; i++)
	{
		if(i == (digit - decimal))
		{
			lStr_buff[i] = '.';
		}
		else
		{
			if(numb < pow)
			{
				if(f_fill == TRUE)
					lStr_buff[i] = '0';
				else
				{
					if(i >= (digit - decimal - 1))		lStr_buff[i] = '0';
					else								lStr_buff[i] = ' ';
				}
			}
			else
			{
				lStr_buff[i] = (numb / pow) % 10 + '0';
			}

			pow /= 10;
		}
	}
	lStr_buff[i] = 0;

	return lStr_buff;
}

void STR_ProcMain(void)
{

}


//------------------------------------------------------------------------------------------------------------------------------
//  EOF
//------------------------------------------------------------------------------------------------------------------------------

